# Keil uVision project artinx_bot.uvprojx, settings and files
target standard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: artinx_bot +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --cpp
  c include: .\STM32F4xx_StdPeriph_Driver\inc;.\CORE;.\rt_thread;.\rt_thread\finsh;.\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx_it.c util.c
  group main
    ./src/: main.cpp
  group RT_Thread
    ./rt_thread/: rtconfig.h board.c context_rvds.S cpuport.c clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group FinSH
    ./rt_thread/finsh/: cmd.c msh.c shell.c finsh_device.c
  group stdperiph_lib
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group debug
    ./src/test/: music.c sorftware_simulation_test.cpp
  group BSP
    ./src/bsp/: bsp_buzzer.c bsp_rc.c bsp_can.c
  group Device
    ./src/device/: device_buzzer.cpp device_rc.cpp device_m3508.cpp
  group Updater
    ./src/: RcUpdater.cpp
  group Math
    ./src/mathlib/: math_pid.cpp
  group Parameter
    ./src/: thread_param.h
